# Keil uVision project Lab3.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers
    ./drivers/: adc.c adc.h comparator.c comparator.h delay.c delay.h delay_as.s gpio.c gpio.h i2c.c i2c.h leds.c leds.h platform.h queue.c queue.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_usart.c stm32f4xx_usart.h timer.c timer.h uart.c uart.h
  group Core
    ./src/: main.c event_handlers.c event_handlers.h system_config.h
  group DHT11
    ./src/: dht11.h dht11.c
  group Middleware
    ./src/: system_control.c system_control.h user_auth.c user_auth.h console.h console.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS-Compiler:STDIN:ITM 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS:CORE 6.1.0, Device:Startup 2.6.3
